Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Element Parameters: Off], Option [IFC Base Quantities: Off], Option [Window Door Lining and Panel Parameters: Off], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off]
File name: /Users/thiagomundim/Desktop/Exercise Files/Ch 05/05_01/Structural File.ifc
Time: 2016-05-05T13:53:13
Author: Ideia1 Arquitetura
Organization: Ideia1 Arquitetura
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 20.0.0 INT FULL Macintosh version (IFC2x3 add-on version: 2352 INT FULL).
Authorization: Ideia1 Arquitetura

# IfcProject, Grove House
Description: Residential House; Phase: Schematic Design

# IfcSite, Grove Residential
RefLatitude: 24, 28, 0, 0; RefLongitude: 54, 25, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (3)
In: Building
Name | Elevation (mm)
Basement | -3060
Ground Floor | 0
First Floor | 3740

# IfcBeam: Concrete - Structural 150 x 300 (3)
In: Ground Floor
Material: Concrete - Structural
KRION - FactoryMolded: no
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Reference: Concrete - Structural 150 x 300
Name
BMR - 003
2 x BMR - 002

# IfcBeam: Concrete - Structural 150 x 450 (3)
In: Ground Floor
Material: Concrete - Structural
KRION - FactoryMolded: no
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Reference: Concrete - Structural 150 x 450
Name
2 x BMR - 003
BMR - 002

# IfcBeam: Concrete - Structural 150 x 500 (21)
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Reference: Concrete - Structural 150 x 500
Name | In
7 x BMR - 002 | Basement
BMR - 003 | Basement
5 x BMR - 004 | Basement
6 x BMR - 002 | Ground Floor | KRION - FactoryMolded: no
2 x BMR - 003 | Ground Floor | KRION - FactoryMolded: no

# IfcBeam: Concrete - Structural 150 x 550 (13)
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Reference: Concrete - Structural 150 x 550
Name | In
3 x BMR - 002 | Basement
2 x BMR - 004 | First Floor
6 x BMR - 006 | First Floor
2 x BMR - 005 | First Floor

# IfcBeam: Concrete - Structural 150 x 690 (3)
In: Ground Floor
Material: Concrete - Structural
KRION - FactoryMolded: no
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Reference: Concrete - Structural 150 x 690
Name
BMR - 003
2 x BMR - 002

# IfcBeam: Concrete - Structural 150 x 700 (7)
In: Ground Floor
Material: Concrete - Structural
KRION - FactoryMolded: no
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Reference: Concrete - Structural 150 x 700

# IfcBeam: Concrete - Structural 150 x 800 (3)
In: Ground Floor
Material: Concrete - Structural
KRION - FactoryMolded: no
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Reference: Concrete - Structural 150 x 800

# IfcBeam: Concrete - Structural 150 x 900, BMR - 002
In: Ground Floor
Material: Concrete - Structural
KRION - FactoryMolded: no
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Reference: Concrete - Structural 150 x 900

# IfcColumn: Concrete - Structural 150 x 400 (40)
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_ColumnCommon - Reference: Concrete - Structural 150 x 400
Name | In
13 x CRE - 001 | Basement
11 x CRE - 001 | Ground Floor
16 x CRE - 001 | First Floor

# IfcColumn: Concrete - Structural 150 x 785 (2)
In: Ground Floor
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_ColumnCommon - Reference: Concrete - Structural 150 x 785

# IfcColumn: Concrete - Structural 200 x 400 (2)
In: Basement
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_ColumnCommon - Reference: Concrete - Structural 200 x 400

# IfcColumn: Concrete - Structural 250 x 150 (2)
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_ColumnCommon - Reference: Concrete - Structural 250 x 150
Name | In
CRE - 001 | Ground Floor
CRE - 001 | First Floor

# IfcColumn: Concrete - Structural 300 x 150, CRE - 001
In: First Floor
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_ColumnCommon - Reference: Concrete - Structural 300 x 150

# IfcColumn: Concrete - Structural 400 x 150 (2)
In: Ground Floor
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_ColumnCommon - Reference: Concrete - Structural 400 x 150

# IfcColumn: Concrete - Structural 570 x 150 (6)
Material: Concrete - Structural
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_ColumnCommon - Reference: Concrete - Structural 570 x 150
Name | In
3 x CRE - 001 | Basement
3 x CRE - 001 | Ground Floor
